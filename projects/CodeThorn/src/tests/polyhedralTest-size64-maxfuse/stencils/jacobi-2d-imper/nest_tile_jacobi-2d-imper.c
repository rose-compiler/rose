#   define TSTEPS STEPSIZE
#   define N ARRAYSIZE
# define _PB_TSTEPS STEPSIZE 
# define _PB_N ARRAYSIZE 

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 64;
  int tsteps = 2;
/* Variable declaration/allocation. */
  double A[64][64];
  double B[64][64];
  int t;
  int i;
  int j;
  
#pragma scop
{
    int c2;
    int c4;
    int c0;
    int c3;
    for (c0 = 0; c0 <= 16; c0++) {
      for (c2 = (1 > 4 * c0 + -61?1 : 4 * c0 + -61); c2 <= ((65 < 2 * c0 + 64?65 : 2 * c0 + 64)); c2++) {
        if (c0 <= (((c2 + -1) * 4 < 0?((4 < 0?-((-(c2 + -1) + 4 + 1) / 4) : -((-(c2 + -1) + 4 - 1) / 4))) : (c2 + -1) / 4)) && c2 >= 63) {
          if ((c2 + 1) % 2 == 0) {
            for (c4 = (4 * c0 > c2 + -61?4 * c0 : c2 + -61); c4 <= ((c2 < 4 * c0 + 3?c2 : 4 * c0 + 3)); c4++) {
              A[-1 * c2 + c4 + 62][62] = B[-1 * c2 + c4 + 62][62];
            }
          }
        }
        for (c3 = (((0 > (((c2 + -62) * 2 < 0?-(-(c2 + -62) / 2) : ((2 < 0?(-(c2 + -62) + - 2 - 1) / - 2 : (c2 + -62 + 2 - 1) / 2))))?0 : (((c2 + -62) * 2 < 0?-(-(c2 + -62) / 2) : ((2 < 0?(-(c2 + -62) + - 2 - 1) / - 2 : (c2 + -62 + 2 - 1) / 2)))))) > 2 * c0 + -31?((0 > (((c2 + -62) * 2 < 0?-(-(c2 + -62) / 2) : ((2 < 0?(-(c2 + -62) + - 2 - 1) / - 2 : (c2 + -62 + 2 - 1) / 2))))?0 : (((c2 + -62) * 2 < 0?-(-(c2 + -62) / 2) : ((2 < 0?(-(c2 + -62) + - 2 - 1) / - 2 : (c2 + -62 + 2 - 1) / 2)))))) : 2 * c0 + -31); c3 <= ((((1 < (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2))?1 : (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2)))) < 2 * c0?((1 < (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2))?1 : (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2)))) : 2 * c0)); c3++) {
          if (c0 == 0 && c3 == 0) {
            B[1][c2] = 0.2 * (A[1][c2] + A[1][c2 - 1] + A[1][1 + c2] + A[1 + 1][c2] + A[1 - 1][c2]);
          }
          for (c4 = (4 * c0 > 2 * c3 + 2?4 * c0 : 2 * c3 + 2); c4 <= ((4 * c0 + 3 < 2 * c3 + 62?4 * c0 + 3 : 2 * c3 + 62)); c4++) {
            A[-2 * c3 + c4 + -1][c2 + -2 * c3 + -1] = B[-2 * c3 + c4 + -1][c2 + -2 * c3 + -1];
            B[-2 * c3 + c4][c2 + -2 * c3] = 0.2 * (A[-2 * c3 + c4][c2 + -2 * c3] + A[-2 * c3 + c4][c2 + -2 * c3 - 1] + A[-2 * c3 + c4][1 + (c2 + -2 * c3)] + A[1 + (-2 * c3 + c4)][c2 + -2 * c3] + A[-2 * c3 + c4 - 1][c2 + -2 * c3]);
          }
          if (c0 == c3 + 15) {
            A[62][-2 * c0 + c2 + 29] = B[62][-2 * c0 + c2 + 29];
          }
        }
        if (c0 >= (((c2 + -1) * 4 < 0?-(-(c2 + -1) / 4) : ((4 < 0?(-(c2 + -1) + - 4 - 1) / - 4 : (c2 + -1 + 4 - 1) / 4)))) && c2 <= 3) {
          if ((c2 + 1) % 2 == 0) {
            for (c4 = (4 * c0 > c2?4 * c0 : c2); c4 <= ((4 * c0 + 3 < c2 + 61?4 * c0 + 3 : c2 + 61)); c4++) {
              B[-1 * c2 + c4 + 1][1] = 0.2 * (A[-1 * c2 + c4 + 1][1] + A[-1 * c2 + c4 + 1][1 - 1] + A[-1 * c2 + c4 + 1][1 + 1] + A[1 + (-1 * c2 + c4 + 1)][1] + A[-1 * c2 + c4 + 1 - 1][1]);
            }
          }
        }
        if (c0 == 0 && c2 >= 3) {
          B[1][c2 + -2] = 0.2 * (A[1][c2 + -2] + A[1][c2 + -2 - 1] + A[1][1 + (c2 + -2)] + A[1 + 1][c2 + -2] + A[1 - 1][c2 + -2]);
        }
      }
    }
  }
  
#pragma endscop
  return 0;
}
