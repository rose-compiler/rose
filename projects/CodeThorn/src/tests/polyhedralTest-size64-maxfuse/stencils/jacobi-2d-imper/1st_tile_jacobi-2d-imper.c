#   define TSTEPS STEPSIZE
#   define N ARRAYSIZE
# define _PB_TSTEPS STEPSIZE 
# define _PB_N ARRAYSIZE 

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 64;
  int tsteps = 2;
/* Variable declaration/allocation. */
  double A[64][64];
  double B[64][64];
  int t;
  int i;
  int j;
  
#pragma scop
{
    int c2;
    int c0;
    int c3;
    for (c0 = 1; c0 <= 65; c0++) {
      for (c2 = (1 > c0 + -61?1 : c0 + -61); c2 <= ((65 < c0 + 61?65 : c0 + 61)); c2++) {
        if (c0 <= c2 + -1 && c2 >= 63) {
          if ((c2 + 1) % 2 == 0) {
            A[c0 + -1 * c2 + 62][62] = B[c0 + -1 * c2 + 62][62];
          }
        }
        if (c0 >= ((63 > c2?63 : c2))) {
          if ((c0 + 1) % 2 == 0) {
            A[62][-1 * c0 + c2 + 62] = B[62][-1 * c0 + c2 + 62];
          }
        }
        for (c3 = (((0 > (((c0 + -62) * 2 < 0?-(-(c0 + -62) / 2) : ((2 < 0?(-(c0 + -62) + - 2 - 1) / - 2 : (c0 + -62 + 2 - 1) / 2))))?0 : (((c0 + -62) * 2 < 0?-(-(c0 + -62) / 2) : ((2 < 0?(-(c0 + -62) + - 2 - 1) / - 2 : (c0 + -62 + 2 - 1) / 2)))))) > (((c2 + -62) * 2 < 0?-(-(c2 + -62) / 2) : ((2 < 0?(-(c2 + -62) + - 2 - 1) / - 2 : (c2 + -62 + 2 - 1) / 2))))?((0 > (((c0 + -62) * 2 < 0?-(-(c0 + -62) / 2) : ((2 < 0?(-(c0 + -62) + - 2 - 1) / - 2 : (c0 + -62 + 2 - 1) / 2))))?0 : (((c0 + -62) * 2 < 0?-(-(c0 + -62) / 2) : ((2 < 0?(-(c0 + -62) + - 2 - 1) / - 2 : (c0 + -62 + 2 - 1) / 2)))))) : (((c2 + -62) * 2 < 0?-(-(c2 + -62) / 2) : ((2 < 0?(-(c2 + -62) + - 2 - 1) / - 2 : (c2 + -62 + 2 - 1) / 2))))); c3 <= ((((1 < (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2))?1 : (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2)))) < (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2))?((1 < (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2))?1 : (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2)))) : (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2)))); c3++) {
          A[c0 + -2 * c3 + -1][c2 + -2 * c3 + -1] = B[c0 + -2 * c3 + -1][c2 + -2 * c3 + -1];
          B[c0 + -2 * c3][c2 + -2 * c3] = 0.2 * (A[c0 + -2 * c3][c2 + -2 * c3] + A[c0 + -2 * c3][c2 + -2 * c3 - 1] + A[c0 + -2 * c3][1 + (c2 + -2 * c3)] + A[1 + (c0 + -2 * c3)][c2 + -2 * c3] + A[c0 + -2 * c3 - 1][c2 + -2 * c3]);
        }
        if (c0 >= c2 + 1 && c2 <= 3) {
          if ((c2 + 1) % 2 == 0) {
            B[c0 + -1 * c2 + 1][1] = 0.2 * (A[c0 + -1 * c2 + 1][1] + A[c0 + -1 * c2 + 1][1 - 1] + A[c0 + -1 * c2 + 1][1 + 1] + A[1 + (c0 + -1 * c2 + 1)][1] + A[c0 + -1 * c2 + 1 - 1][1]);
          }
        }
        if (c0 <= ((3 < c2?3 : c2))) {
          if ((c0 + 1) % 2 == 0) {
            B[1][-1 * c0 + c2 + 1] = 0.2 * (A[1][-1 * c0 + c2 + 1] + A[1][-1 * c0 + c2 + 1 - 1] + A[1][1 + (-1 * c0 + c2 + 1)] + A[1 + 1][-1 * c0 + c2 + 1] + A[1 - 1][-1 * c0 + c2 + 1]);
          }
        }
      }
    }
  }
  
#pragma endscop
  return 0;
}
