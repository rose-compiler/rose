/* Default data type is double, default size is 20x1000. */
#include "jacobi-2d-imper.h"

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 16;
  int tsteps = 2;
/* Variable declaration/allocation. */
  double A[16][16];
  double B[16][16];
  int t;
  int i;
  int j;
  
#pragma scop
{
    int c2;
    int c0;
    int c3;
    for (c0 = 1; c0 <= 17; c0++) {
      for (c2 = (1 > c0 + -13?1 : c0 + -13); c2 <= ((17 < c0 + 13?17 : c0 + 13)); c2++) {
        if (c0 <= c2 + -1 && c2 >= 15) {
          if ((c2 + 1) % 2 == 0) {
            A[c0 + -1 * c2 + 14][14] = B[c0 + -1 * c2 + 14][14];
          }
        }
        if (c0 >= ((15 > c2?15 : c2))) {
          if ((c0 + 1) % 2 == 0) {
            A[14][-1 * c0 + c2 + 14] = B[14][-1 * c0 + c2 + 14];
          }
        }
        for (c3 = (((0 > (((c0 + -14) * 2 < 0?-(-(c0 + -14) / 2) : ((2 < 0?(-(c0 + -14) + - 2 - 1) / - 2 : (c0 + -14 + 2 - 1) / 2))))?0 : (((c0 + -14) * 2 < 0?-(-(c0 + -14) / 2) : ((2 < 0?(-(c0 + -14) + - 2 - 1) / - 2 : (c0 + -14 + 2 - 1) / 2)))))) > (((c2 + -14) * 2 < 0?-(-(c2 + -14) / 2) : ((2 < 0?(-(c2 + -14) + - 2 - 1) / - 2 : (c2 + -14 + 2 - 1) / 2))))?((0 > (((c0 + -14) * 2 < 0?-(-(c0 + -14) / 2) : ((2 < 0?(-(c0 + -14) + - 2 - 1) / - 2 : (c0 + -14 + 2 - 1) / 2))))?0 : (((c0 + -14) * 2 < 0?-(-(c0 + -14) / 2) : ((2 < 0?(-(c0 + -14) + - 2 - 1) / - 2 : (c0 + -14 + 2 - 1) / 2)))))) : (((c2 + -14) * 2 < 0?-(-(c2 + -14) / 2) : ((2 < 0?(-(c2 + -14) + - 2 - 1) / - 2 : (c2 + -14 + 2 - 1) / 2))))); c3 <= ((((1 < (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2))?1 : (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2)))) < (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2))?((1 < (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2))?1 : (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2)))) : (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2)))); c3++) {
          A[c0 + -2 * c3 + -1][c2 + -2 * c3 + -1] = B[c0 + -2 * c3 + -1][c2 + -2 * c3 + -1];
          B[c0 + -2 * c3][c2 + -2 * c3] = 0.2 * (A[c0 + -2 * c3][c2 + -2 * c3] + A[c0 + -2 * c3][c2 + -2 * c3 - 1] + A[c0 + -2 * c3][1 + (c2 + -2 * c3)] + A[1 + (c0 + -2 * c3)][c2 + -2 * c3] + A[c0 + -2 * c3 - 1][c2 + -2 * c3]);
        }
        if (c0 >= c2 + 1 && c2 <= 3) {
          if ((c2 + 1) % 2 == 0) {
            B[c0 + -1 * c2 + 1][1] = 0.2 * (A[c0 + -1 * c2 + 1][1] + A[c0 + -1 * c2 + 1][1 - 1] + A[c0 + -1 * c2 + 1][1 + 1] + A[1 + (c0 + -1 * c2 + 1)][1] + A[c0 + -1 * c2 + 1 - 1][1]);
          }
        }
        if (c0 <= ((3 < c2?3 : c2))) {
          if ((c0 + 1) % 2 == 0) {
            B[1][-1 * c0 + c2 + 1] = 0.2 * (A[1][-1 * c0 + c2 + 1] + A[1][-1 * c0 + c2 + 1 - 1] + A[1][1 + (-1 * c0 + c2 + 1)] + A[1 + 1][-1 * c0 + c2 + 1] + A[1 - 1][-1 * c0 + c2 + 1]);
          }
        }
      }
    }
  }
  
#pragma endscop
  return 0;
}
