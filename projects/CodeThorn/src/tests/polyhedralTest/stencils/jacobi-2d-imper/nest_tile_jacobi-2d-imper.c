/* Default data type is double, default size is 20x1000. */
#include "jacobi-2d-imper.h"

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 16;
  int tsteps = 2;
/* Variable declaration/allocation. */
  double A[16][16];
  double B[16][16];
  int t;
  int i;
  int j;
  
#pragma scop
{
    int c4;
    int c0;
    int c3;
    int c2;
    for (c0 = 0; c0 <= 4; c0++) {
      for (c2 = (1 > 4 * c0 + -13?1 : 4 * c0 + -13); c2 <= ((17 < 2 * c0 + 16?17 : 2 * c0 + 16)); c2++) {
        if (c0 <= (((c2 + -1) * 4 < 0?((4 < 0?-((-(c2 + -1) + 4 + 1) / 4) : -((-(c2 + -1) + 4 - 1) / 4))) : (c2 + -1) / 4)) && c2 >= 15) {
          if ((c2 + 1) % 2 == 0) {
            for (c4 = (4 * c0 > c2 + -13?4 * c0 : c2 + -13); c4 <= ((c2 < 4 * c0 + 3?c2 : 4 * c0 + 3)); c4++) {
              A[-1 * c2 + c4 + 14][14] = B[-1 * c2 + c4 + 14][14];
            }
          }
        }
        for (c3 = (((0 > (((c2 + -14) * 2 < 0?-(-(c2 + -14) / 2) : ((2 < 0?(-(c2 + -14) + - 2 - 1) / - 2 : (c2 + -14 + 2 - 1) / 2))))?0 : (((c2 + -14) * 2 < 0?-(-(c2 + -14) / 2) : ((2 < 0?(-(c2 + -14) + - 2 - 1) / - 2 : (c2 + -14 + 2 - 1) / 2)))))) > 2 * c0 + -7?((0 > (((c2 + -14) * 2 < 0?-(-(c2 + -14) / 2) : ((2 < 0?(-(c2 + -14) + - 2 - 1) / - 2 : (c2 + -14 + 2 - 1) / 2))))?0 : (((c2 + -14) * 2 < 0?-(-(c2 + -14) / 2) : ((2 < 0?(-(c2 + -14) + - 2 - 1) / - 2 : (c2 + -14 + 2 - 1) / 2)))))) : 2 * c0 + -7); c3 <= ((((1 < (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2))?1 : (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2)))) < 2 * c0?((1 < (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2))?1 : (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2)))) : 2 * c0)); c3++) {
          if (c0 == 0 && c3 == 0) {
            B[1][c2] = 0.2 * (A[1][c2] + A[1][c2 - 1] + A[1][1 + c2] + A[1 + 1][c2] + A[1 - 1][c2]);
          }
          for (c4 = (4 * c0 > 2 * c3 + 2?4 * c0 : 2 * c3 + 2); c4 <= ((4 * c0 + 3 < 2 * c3 + 14?4 * c0 + 3 : 2 * c3 + 14)); c4++) {
            A[-2 * c3 + c4 + -1][c2 + -2 * c3 + -1] = B[-2 * c3 + c4 + -1][c2 + -2 * c3 + -1];
            B[-2 * c3 + c4][c2 + -2 * c3] = 0.2 * (A[-2 * c3 + c4][c2 + -2 * c3] + A[-2 * c3 + c4][c2 + -2 * c3 - 1] + A[-2 * c3 + c4][1 + (c2 + -2 * c3)] + A[1 + (-2 * c3 + c4)][c2 + -2 * c3] + A[-2 * c3 + c4 - 1][c2 + -2 * c3]);
          }
          if (c0 == c3 + 3) {
            A[14][-2 * c0 + c2 + 5] = B[14][-2 * c0 + c2 + 5];
          }
        }
        if (c0 >= (((c2 + -1) * 4 < 0?-(-(c2 + -1) / 4) : ((4 < 0?(-(c2 + -1) + - 4 - 1) / - 4 : (c2 + -1 + 4 - 1) / 4)))) && c2 <= 3) {
          if ((c2 + 1) % 2 == 0) {
            for (c4 = (4 * c0 > c2?4 * c0 : c2); c4 <= ((4 * c0 + 3 < c2 + 13?4 * c0 + 3 : c2 + 13)); c4++) {
              B[-1 * c2 + c4 + 1][1] = 0.2 * (A[-1 * c2 + c4 + 1][1] + A[-1 * c2 + c4 + 1][1 - 1] + A[-1 * c2 + c4 + 1][1 + 1] + A[1 + (-1 * c2 + c4 + 1)][1] + A[-1 * c2 + c4 + 1 - 1][1]);
            }
          }
        }
        if (c0 == 0 && c2 >= 3) {
          B[1][c2 + -2] = 0.2 * (A[1][c2 + -2] + A[1][c2 + -2 - 1] + A[1][1 + (c2 + -2)] + A[1 + 1][c2 + -2] + A[1 - 1][c2 + -2]);
        }
      }
    }
  }
  
#pragma endscop
  return 0;
}
