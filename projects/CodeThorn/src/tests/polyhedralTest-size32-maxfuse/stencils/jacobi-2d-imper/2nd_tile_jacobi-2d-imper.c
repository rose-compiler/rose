#   define TSTEPS STEPSIZE
#   define N ARRAYSIZE
# define _PB_TSTEPS STEPSIZE 
# define _PB_N ARRAYSIZE 

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 32;
  int tsteps = 2;
/* Variable declaration/allocation. */
  double A[32][32];
  double B[32][32];
  int t;
  int i;
  int j;
  
#pragma scop
{
    int c2;
    int c0;
    int c3;
    for (c0 = 1; c0 <= 33; c0++) {
      for (c2 = (1 > c0 + - 29?1 : c0 + - 29); c2 <= ((33 < c0 + 29?33 : c0 + 29)); c2++) {
        if (c0 <= c2 + - 1 && c2 >= 31) {
          if ((c2 + 1) % 2 == 0) {
            A[c0 + - 1 * c2 + 30][30] = B[c0 + - 1 * c2 + 30][30];
          }
        }
        if (c0 >= ((31 > c2?31 : c2))) {
          if ((c0 + 1) % 2 == 0) {
            A[30][- 1 * c0 + c2 + 30] = B[30][- 1 * c0 + c2 + 30];
          }
        }
{
          int c5;
          if (c0 >= 2 && c0 <= 32 && c2 >= 2 && c2 <= 32 && c2 >= c0 + -28 && c2 <= c0 + 28) {
            for (c5 = (((0 > (((c0 + -30) * 2 < 0?-(-(c0 + -30) / 2) : ((2 < 0?(-(c0 + -30) + - 2 - 1) / - 2 : (c0 + -30 + 2 - 1) / 2))))?0 : (((c0 + -30) * 2 < 0?-(-(c0 + -30) / 2) : ((2 < 0?(-(c0 + -30) + - 2 - 1) / - 2 : (c0 + -30 + 2 - 1) / 2)))))) > (((c2 + -30) * 2 < 0?-(-(c2 + -30) / 2) : ((2 < 0?(-(c2 + -30) + - 2 - 1) / - 2 : (c2 + -30 + 2 - 1) / 2))))?((0 > (((c0 + -30) * 2 < 0?-(-(c0 + -30) / 2) : ((2 < 0?(-(c0 + -30) + - 2 - 1) / - 2 : (c0 + -30 + 2 - 1) / 2))))?0 : (((c0 + -30) * 2 < 0?-(-(c0 + -30) / 2) : ((2 < 0?(-(c0 + -30) + - 2 - 1) / - 2 : (c0 + -30 + 2 - 1) / 2)))))) : (((c2 + -30) * 2 < 0?-(-(c2 + -30) / 2) : ((2 < 0?(-(c2 + -30) + - 2 - 1) / - 2 : (c2 + -30 + 2 - 1) / 2))))); c5 <= ((((1 < (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2))?1 : (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2)))) < (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2))?((1 < (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2))?1 : (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2)))) : (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2)))); c5++) {
              A[c0 + - 2 * c5 + - 1][c2 + - 2 * c5 + - 1] = B[c0 + - 2 * c5 + - 1][c2 + - 2 * c5 + - 1];
              B[c0 + - 2 * c5][c2 + - 2 * c5] = 0.2 * (A[c0 + - 2 * c5][c2 + - 2 * c5] + A[c0 + - 2 * c5][c2 + - 2 * c5 - 1] + A[c0 + - 2 * c5][1 + (c2 + - 2 * c5)] + A[1 + (c0 + - 2 * c5)][c2 + - 2 * c5] + A[c0 + - 2 * c5 - 1][c2 + - 2 * c5]);
            }
          }
        }
        if (c0 >= c2 + 1 && c2 <= 3) {
          if ((c2 + 1) % 2 == 0) {
            B[c0 + - 1 * c2 + 1][1] = 0.2 * (A[c0 + - 1 * c2 + 1][1] + A[c0 + - 1 * c2 + 1][1 - 1] + A[c0 + - 1 * c2 + 1][1 + 1] + A[1 + (c0 + - 1 * c2 + 1)][1] + A[c0 + - 1 * c2 + 1 - 1][1]);
          }
        }
        if (c0 <= ((3 < c2?3 : c2))) {
          if ((c0 + 1) % 2 == 0) {
            B[1][- 1 * c0 + c2 + 1] = 0.2 * (A[1][- 1 * c0 + c2 + 1] + A[1][- 1 * c0 + c2 + 1 - 1] + A[1][1 + (- 1 * c0 + c2 + 1)] + A[1 + 1][- 1 * c0 + c2 + 1] + A[1 - 1][- 1 * c0 + c2 + 1]);
          }
        }
      }
    }
  }
  
#pragma endscop
  return 0;
}
