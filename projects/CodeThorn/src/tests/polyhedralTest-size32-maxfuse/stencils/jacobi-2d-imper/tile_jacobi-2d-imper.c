#   define TSTEPS STEPSIZE
#   define N ARRAYSIZE
# define _PB_TSTEPS STEPSIZE 
# define _PB_N ARRAYSIZE 

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 32;
  int tsteps = 2;
/* Variable declaration/allocation. */
  double A[32][32];
  double B[32][32];
  int t;
  int i;
  int j;
  
#pragma scop
{
    int c1;
    int c2;
    int c0;
{
      int c5;
      int c4;
      int c3;
      for (c3 = 0; c3 <= 1; c3++) {
        B[1][- 2 * c3 + (2 * c3 + 1)] = 0.2 * (A[1][- 2 * c3 + (2 * c3 + 1)] + A[1][- 2 * c3 + (2 * c3 + 1) - 1] + A[1][1 + (- 2 * c3 + (2 * c3 + 1))] + A[1 + 1][- 2 * c3 + (2 * c3 + 1)] + A[1 - 1][- 2 * c3 + (2 * c3 + 1)]);
        for (c4 = 2 * c3 + 2; c4 <= ((2 * c3 + 30 < 20 * c3 + 29?2 * c3 + 30 : 20 * c3 + 29)); c4++) {
          B[1][- 2 * c3 + c4] = 0.2 * (A[1][- 2 * c3 + c4] + A[1][- 2 * c3 + c4 - 1] + A[1][1 + (- 2 * c3 + c4)] + A[1 + 1][- 2 * c3 + c4] + A[1 - 1][- 2 * c3 + c4]);
          B[- 2 * c3 + c4][1] = 0.2 * (A[- 2 * c3 + c4][1] + A[- 2 * c3 + c4][1 - 1] + A[- 2 * c3 + c4][1 + 1] + A[1 + (- 2 * c3 + c4)][1] + A[- 2 * c3 + c4 - 1][1]);
          for (c5 = 8 * c3 + 2; c5 <= 8 * c3 + 30; c5++) {
            B[- 2 * c3 + c4][- 2 * c3 + (-6 * c3 + c5)] = 0.2 * (A[- 2 * c3 + c4][- 2 * c3 + (-6 * c3 + c5)] + A[- 2 * c3 + c4][- 2 * c3 + (-6 * c3 + c5) - 1] + A[- 2 * c3 + c4][1 + (- 2 * c3 + (-6 * c3 + c5))] + A[1 + (- 2 * c3 + c4)][- 2 * c3 + (-6 * c3 + c5)] + A[- 2 * c3 + c4 - 1][- 2 * c3 + (-6 * c3 + c5)]);
          }
        }
        if (c3 == 0) {
          B[1][- 2 * 0 + 30] = 0.2 * (A[1][- 2 * 0 + 30] + A[1][- 2 * 0 + 30 - 1] + A[1][1 + (- 2 * 0 + 30)] + A[1 + 1][- 2 * 0 + 30] + A[1 - 1][- 2 * 0 + 30]);
          B[- 2 * 0 + 30][1] = 0.2 * (A[- 2 * 0 + 30][1] + A[- 2 * 0 + 30][1 - 1] + A[- 2 * 0 + 30][1 + 1] + A[1 + (- 2 * 0 + 30)][1] + A[- 2 * 0 + 30 - 1][1]);
          for (c5 = 2; c5 <= 7; c5++) {
            B[- 2 * 0 + 30][- 2 * 0 + c5] = 0.2 * (A[- 2 * 0 + 30][- 2 * 0 + c5] + A[- 2 * 0 + 30][- 2 * 0 + c5 - 1] + A[- 2 * 0 + 30][1 + (- 2 * 0 + c5)] + A[1 + (- 2 * 0 + 30)][- 2 * 0 + c5] + A[- 2 * 0 + 30 - 1][- 2 * 0 + c5]);
          }
          B[- 2 * 0 + 30][- 2 * 0 + 8] = 0.2 * (A[- 2 * 0 + 30][- 2 * 0 + 8] + A[- 2 * 0 + 30][- 2 * 0 + 8 - 1] + A[- 2 * 0 + 30][1 + (- 2 * 0 + 8)] + A[1 + (- 2 * 0 + 30)][- 2 * 0 + 8] + A[- 2 * 0 + 30 - 1][- 2 * 0 + 8]);
          A[30][- 2 * 0 + 2 + - 1] = B[30][- 2 * 0 + 2 + - 1];
          A[- 2 * 0 + 2 + - 1][- 2 * 0 + 2 + - 1] = B[- 2 * 0 + 2 + - 1][- 2 * 0 + 2 + - 1];
          for (c5 = 9; c5 <= 29; c5++) {
            B[- 2 * 0 + 30][- 2 * 0 + c5] = 0.2 * (A[- 2 * 0 + 30][- 2 * 0 + c5] + A[- 2 * 0 + 30][- 2 * 0 + c5 - 1] + A[- 2 * 0 + 30][1 + (- 2 * 0 + c5)] + A[1 + (- 2 * 0 + 30)][- 2 * 0 + c5] + A[- 2 * 0 + 30 - 1][- 2 * 0 + c5]);
            A[- 2 * 0 + 2 + - 1][- 2 * 0 + (c5 + -6) + - 1] = B[- 2 * 0 + 2 + - 1][- 2 * 0 + (c5 + -6) + - 1];
          }
          A[- 2 * 0 + 2 + - 1][30] = B[- 2 * 0 + 2 + - 1][30];
          B[- 2 * 0 + 30][- 2 * 0 + 30] = 0.2 * (A[- 2 * 0 + 30][- 2 * 0 + 30] + A[- 2 * 0 + 30][- 2 * 0 + 30 - 1] + A[- 2 * 0 + 30][1 + (- 2 * 0 + 30)] + A[1 + (- 2 * 0 + 30)][- 2 * 0 + 30] + A[- 2 * 0 + 30 - 1][- 2 * 0 + 30]);
          A[- 2 * 0 + 2 + - 1][- 2 * 0 + 24 + - 1] = B[- 2 * 0 + 2 + - 1][- 2 * 0 + 24 + - 1];
          for (c5 = 31; c5 <= 36; c5++) {
            A[- 2 * 0 + 2 + - 1][- 2 * 0 + (c5 + -6) + - 1] = B[- 2 * 0 + 2 + - 1][- 2 * 0 + (c5 + -6) + - 1];
          }
        }
        for (c4 = (40 > 20 * c3 + 30?40 : 20 * c3 + 30); c4 <= 20 * c3 + 310; c4 = c4 + 10) {
          for (c5 = 2 * c3 + 8; c5 <= (((c4 + 49) * 10 < 0?((10 < 0?-((-(c4 + 49) + 10 + 1) / 10) : -((-(c4 + 49) + 10 - 1) / 10))) : (c4 + 49) / 10)); c5++) {
            A[- 2 * c3 + (c4 + -10) / 10 + - 1][- 2 * c3 + (c5 + -6) + - 1] = B[- 2 * c3 + (c4 + -10) / 10 + - 1][- 2 * c3 + (c5 + -6) + - 1];
          }
          A[30][- 2 * c3 + (c4 + -10) / 10 + - 1] = B[30][- 2 * c3 + (c4 + -10) / 10 + - 1];
          A[- 2 * c3 + (c4 + -10) / 10 + - 1][- 2 * c3 + (c4 + -10) / 10 + - 1] = B[- 2 * c3 + (c4 + -10) / 10 + - 1][- 2 * c3 + (c4 + -10) / 10 + - 1];
          for (c5 = ((c4 + 51) * 10 < 0?-(-(c4 + 51) / 10) : ((10 < 0?(-(c4 + 51) + - 10 - 1) / - 10 : (c4 + 51 + 10 - 1) / 10))); c5 <= 2 * c3 + 36; c5++) {
            A[- 2 * c3 + (c4 + -10) / 10 + - 1][- 2 * c3 + (c5 + -6) + - 1] = B[- 2 * c3 + (c4 + -10) / 10 + - 1][- 2 * c3 + (c5 + -6) + - 1];
          }
          A[- 2 * c3 + (c4 + -10) / 10 + - 1][30] = B[- 2 * c3 + (c4 + -10) / 10 + - 1][30];
        }
        A[30][- 2 * c3 + (2 * c3 + 31) + - 1] = B[30][- 2 * c3 + (2 * c3 + 31) + - 1];
      }
    }
  }
  
#pragma endscop
  return 0;
}
