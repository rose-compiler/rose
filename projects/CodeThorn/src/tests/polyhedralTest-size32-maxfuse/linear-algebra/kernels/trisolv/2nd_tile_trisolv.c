#   define N ARRAYSIZE
# define _PB_N ARRAYSIZE
/**
 * trisolv.c: This file is part of the PolyBench/C 3.2 test suite.
 *
 *
 * Contact: Louis-Noel Pouchet <pouchet@cse.ohio-state.edu>
 * Web address: http://polybench.sourceforge.net
 */
#include <stdio.h>
#include <unistd.h>
#include <string.h>
#include <math.h>

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 32;
/* Variable declaration/allocation. */
  double A[32][32];
  double x[32];
  double c[32];
  int i;
  int j;
  
#pragma scop
{
    int c3;
    int c1;
    int c2;
{
      int c4;
      int c2;
      int c0;
#pragma omp parallel for private(c2)
      for (c0 = 0; c0 <= 1; c0++) {
        for (c2 = 16 * c0; c2 <= 16 * c0 + 15; c2++) {
          c4 = (c2 * 8 < 0?((8 < 0?-((-c2 + 8 + 1) / 8) : -((-c2 + 8 - 1) / 8))) : c2 / 8);
          x[c2] = c[c2];
        }
      }
    }
    for (c1 = 0; c1 <= 35; c1++) {
      
#pragma omp parallel for private(c3)
{
        int c5;
        int c4;
        int c6;
        if (c1 >= 0 && c1 <= 35) {
          if (c1 == 0) {
            x[0] = x[0] / A[0][0];
          }
          if (c1 == 35) {
            x[31] = x[31] / A[31][31];
          }
          if (c1 >= 2 && c1 <= 25) {
#pragma ivdep
#pragma vector always
#pragma simd
            for (c4 = (0 > (((c1 + -4) * 2 < 0?-(-(c1 + -4) / 2) : ((2 < 0?(-(c1 + -4) + - 2 - 1) / - 2 : (c1 + -4 + 2 - 1) / 2))))?0 : (((c1 + -4) * 2 < 0?-(-(c1 + -4) / 2) : ((2 < 0?(-(c1 + -4) + - 2 - 1) / - 2 : (c1 + -4 + 2 - 1) / 2))))); c4 <= (((4 * c1 + -1) * 9 < 0?((9 < 0?-((-(4 * c1 + -1) + 9 + 1) / 9) : -((-(4 * c1 + -1) + 9 - 1) / 9))) : (4 * c1 + -1) / 9)); c4++) {
              for (c5 = ((((8 * c1 + 16) * 9 < 0?-(-(8 * c1 + 16) / 9) : ((9 < 0?(-(8 * c1 + 16) + - 9 - 1) / - 9 : (8 * c1 + 16 + 9 - 1) / 9)))) > -16 * c4 + 8 * c1 + -8?(((8 * c1 + 16) * 9 < 0?-(-(8 * c1 + 16) / 9) : ((9 < 0?(-(8 * c1 + 16) + - 9 - 1) / - 9 : (8 * c1 + 16 + 9 - 1) / 9)))) : -16 * c4 + 8 * c1 + -8); c5 <= ((((31 < 8 * c1 + -1?31 : 8 * c1 + -1)) < -16 * c4 + 8 * c1 + 7?((31 < 8 * c1 + -1?31 : 8 * c1 + -1)) : -16 * c4 + 8 * c1 + 7)); c5++) {
                c6 = ((-1 * c5 + 8 * c1) * 8 < 0?-(-(-1 * c5 + 8 * c1) / 8) : ((8 < 0?(-(-1 * c5 + 8 * c1) + - 8 - 1) / - 8 : (-1 * c5 + 8 * c1 + 8 - 1) / 8)));
                if (c6 <= (((((-1 * c5 + 8 * c1 + 7) * 8 < 0?((8 < 0?-((-(-1 * c5 + 8 * c1 + 7) + 8 + 1) / 8) : -((-(-1 * c5 + 8 * c1 + 7) + 8 - 1) / 8))) : (-1 * c5 + 8 * c1 + 7) / 8)) < (((8 * c1 + -2) * 9 < 0?((9 < 0?-((-(8 * c1 + -2) + 9 + 1) / 9) : -((-(8 * c1 + -2) + 9 - 1) / 9))) : (8 * c1 + -2) / 9))?(((-1 * c5 + 8 * c1 + 7) * 8 < 0?((8 < 0?-((-(-1 * c5 + 8 * c1 + 7) + 8 + 1) / 8) : -((-(-1 * c5 + 8 * c1 + 7) + 8 - 1) / 8))) : (-1 * c5 + 8 * c1 + 7) / 8)) : (((8 * c1 + -2) * 9 < 0?((9 < 0?-((-(8 * c1 + -2) + 9 + 1) / 9) : -((-(8 * c1 + -2) + 9 - 1) / 9))) : (8 * c1 + -2) / 9))))) {
                  x[c5] = x[c5] - A[c5][c6 + - 1] * x[c6 + - 1];
                }
              }
            }
          }
        }
      }
      if ((8 * c1 + 7) % 9 == 0) {
        x[(8 * c1 + 7) / 9] = x[(8 * c1 + 7) / 9] - A[(8 * c1 + 7) / 9][(8 * c1 + - 2) / 9] * x[(8 * c1 + - 2) / 9];
      }
{
        c2 = (((1 > (((8 * c1 + - 1) * 9 < 0?-(-(8 * c1 + - 1) / 9) : ((9 < 0?(-(8 * c1 + - 1) + - 9 - 1) / - 9 : (8 * c1 + - 1 + 9 - 1) / 9))))?1 : (((8 * c1 + - 1) * 9 < 0?-(-(8 * c1 + - 1) / 9) : ((9 < 0?(-(8 * c1 + - 1) + - 9 - 1) / - 9 : (8 * c1 + - 1 + 9 - 1) / 9)))))) > c1 + - 3?((1 > (((8 * c1 + - 1) * 9 < 0?-(-(8 * c1 + - 1) / 9) : ((9 < 0?(-(8 * c1 + - 1) + - 9 - 1) / - 9 : (8 * c1 + - 1 + 9 - 1) / 9))))?1 : (((8 * c1 + - 1) * 9 < 0?-(-(8 * c1 + - 1) / 9) : ((9 < 0?(-(8 * c1 + - 1) + - 9 - 1) / - 9 : (8 * c1 + - 1 + 9 - 1) / 9)))))) : c1 + - 3);
      }
{
        int c5;
        if (8 * c1 >= 9 * c2 + -6) {
          if (c1 >= (((9 * c2 + 1) * 8 < 0?-(-(9 * c2 + 1) / 8) : ((8 < 0?(-(9 * c2 + 1) + - 8 - 1) / - 8 : (9 * c2 + 1 + 8 - 1) / 8)))) && c2 >= -1) {
            x[c2 + 1] = x[c2 + 1] - A[c2 + 1][c2 + - 1] * x[c2 + - 1];
            x[c2] = x[c2] / A[c2][c2];
          }
          for (c5 = c2 + 2; c5 <= ((-1 < 8 * c1 + -8 * c2 + 7?-1 : 8 * c1 + -8 * c2 + 7)); c5++) {
            x[c5] = x[c5] - A[c5][c2 + - 1] * x[c2 + - 1];
          }
          if (c1 <= ((9 * c2 * 8 < 0?((8 < 0?-((-(9 * c2) + 8 + 1) / 8) : -((-(9 * c2) + 8 - 1) / 8))) : 9 * c2 / 8))) {
            x[c2] = x[c2] - A[c2][c2 + - 1] * x[c2 + - 1];
            x[c2 + 1] = x[c2 + 1] - A[c2 + 1][c2 + - 1] * x[c2 + - 1];
            x[c2] = x[c2] / A[c2][c2];
          }
          if (c1 >= c2 && c2 <= -2) {
            x[c2 + 1] = x[c2 + 1] - A[c2 + 1][c2 + - 1] * x[c2 + - 1];
            x[0] = x[0] - A[0][c2 + - 1] * x[c2 + - 1];
            x[c2] = x[c2] / A[c2][c2];
          }
          if (c1 >= (((9 * c2 + 1) * 8 < 0?-(-(9 * c2 + 1) / 8) : ((8 < 0?(-(9 * c2 + 1) + - 8 - 1) / - 8 : (9 * c2 + 1 + 8 - 1) / 8)))) && c1 <= c2 + -1) {
            x[c2 + 1] = x[c2 + 1] - A[c2 + 1][c2 + - 1] * x[c2 + - 1];
            x[c2] = x[c2] / A[c2][c2];
          }
          for (c5 = (1 > c2 + 2?1 : c2 + 2); c5 <= 8 * c1 + -8 * c2 + 7; c5++) {
            x[c5] = x[c5] - A[c5][c2 + - 1] * x[c2 + - 1];
          }
        }
      }
    }
  }
  
#pragma endscop
  return 0;
}
