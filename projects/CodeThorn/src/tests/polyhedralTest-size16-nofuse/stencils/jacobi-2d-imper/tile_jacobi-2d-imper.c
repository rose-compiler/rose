#   define TSTEPS STEPSIZE
#   define N ARRAYSIZE
# define _PB_TSTEPS STEPSIZE 
# define _PB_N ARRAYSIZE 

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 16;
  int tsteps = 2;
/* Variable declaration/allocation. */
  double A[16][16];
  double B[16][16];
  int t;
  int i;
  int j;
  
#pragma scop
{
    int c1;
    int c2;
    int c0;
{
      int c5;
      int c4;
      int c3;
      for (c3 = 0; c3 <= 1; c3++) {
        B[1][- 2 * c3 + (2 * c3 + 1)] = 0.2 * (A[1][- 2 * c3 + (2 * c3 + 1)] + A[1][- 2 * c3 + (2 * c3 + 1) - 1] + A[1][1 + (- 2 * c3 + (2 * c3 + 1))] + A[1 + 1][- 2 * c3 + (2 * c3 + 1)] + A[1 - 1][- 2 * c3 + (2 * c3 + 1)]);
        for (c4 = 2 * c3 + 2; c4 <= ((2 * c3 + 14 < 4 * c3 + 13?2 * c3 + 14 : 4 * c3 + 13)); c4++) {
          B[- 2 * c3 + c4][1] = 0.2 * (A[- 2 * c3 + c4][1] + A[- 2 * c3 + c4][1 - 1] + A[- 2 * c3 + c4][1 + 1] + A[1 + (- 2 * c3 + c4)][1] + A[- 2 * c3 + c4 - 1][1]);
          B[1][- 2 * c3 + c4] = 0.2 * (A[1][- 2 * c3 + c4] + A[1][- 2 * c3 + c4 - 1] + A[1][1 + (- 2 * c3 + c4)] + A[1 + 1][- 2 * c3 + c4] + A[1 - 1][- 2 * c3 + c4]);
          for (c5 = 4 * c3 + 2; c5 <= 4 * c3 + 14; c5++) {
            B[- 2 * c3 + c4][- 2 * c3 + (-2 * c3 + c5)] = 0.2 * (A[- 2 * c3 + c4][- 2 * c3 + (-2 * c3 + c5)] + A[- 2 * c3 + c4][- 2 * c3 + (-2 * c3 + c5) - 1] + A[- 2 * c3 + c4][1 + (- 2 * c3 + (-2 * c3 + c5))] + A[1 + (- 2 * c3 + c4)][- 2 * c3 + (-2 * c3 + c5)] + A[- 2 * c3 + c4 - 1][- 2 * c3 + (-2 * c3 + c5)]);
          }
        }
        if (c3 == 0) {
          B[- 2 * 0 + 14][1] = 0.2 * (A[- 2 * 0 + 14][1] + A[- 2 * 0 + 14][1 - 1] + A[- 2 * 0 + 14][1 + 1] + A[1 + (- 2 * 0 + 14)][1] + A[- 2 * 0 + 14 - 1][1]);
          B[1][- 2 * 0 + 14] = 0.2 * (A[1][- 2 * 0 + 14] + A[1][- 2 * 0 + 14 - 1] + A[1][1 + (- 2 * 0 + 14)] + A[1 + 1][- 2 * 0 + 14] + A[1 - 1][- 2 * 0 + 14]);
          for (c5 = 2; c5 <= 3; c5++) {
            B[- 2 * 0 + 14][- 2 * 0 + c5] = 0.2 * (A[- 2 * 0 + 14][- 2 * 0 + c5] + A[- 2 * 0 + 14][- 2 * 0 + c5 - 1] + A[- 2 * 0 + 14][1 + (- 2 * 0 + c5)] + A[1 + (- 2 * 0 + 14)][- 2 * 0 + c5] + A[- 2 * 0 + 14 - 1][- 2 * 0 + c5]);
          }
          B[- 2 * 0 + 14][- 2 * 0 + 4] = 0.2 * (A[- 2 * 0 + 14][- 2 * 0 + 4] + A[- 2 * 0 + 14][- 2 * 0 + 4 - 1] + A[- 2 * 0 + 14][1 + (- 2 * 0 + 4)] + A[1 + (- 2 * 0 + 14)][- 2 * 0 + 4] + A[- 2 * 0 + 14 - 1][- 2 * 0 + 4]);
          A[14][- 2 * 0 + 2 + - 1] = B[14][- 2 * 0 + 2 + - 1];
          A[- 2 * 0 + 2 + - 1][- 2 * 0 + 2 + - 1] = B[- 2 * 0 + 2 + - 1][- 2 * 0 + 2 + - 1];
          for (c5 = 5; c5 <= 13; c5++) {
            B[- 2 * 0 + 14][- 2 * 0 + c5] = 0.2 * (A[- 2 * 0 + 14][- 2 * 0 + c5] + A[- 2 * 0 + 14][- 2 * 0 + c5 - 1] + A[- 2 * 0 + 14][1 + (- 2 * 0 + c5)] + A[1 + (- 2 * 0 + 14)][- 2 * 0 + c5] + A[- 2 * 0 + 14 - 1][- 2 * 0 + c5]);
            A[- 2 * 0 + 2 + - 1][- 2 * 0 + (c5 + -2) + - 1] = B[- 2 * 0 + 2 + - 1][- 2 * 0 + (c5 + -2) + - 1];
          }
          A[- 2 * 0 + 2 + - 1][14] = B[- 2 * 0 + 2 + - 1][14];
          B[- 2 * 0 + 14][- 2 * 0 + 14] = 0.2 * (A[- 2 * 0 + 14][- 2 * 0 + 14] + A[- 2 * 0 + 14][- 2 * 0 + 14 - 1] + A[- 2 * 0 + 14][1 + (- 2 * 0 + 14)] + A[1 + (- 2 * 0 + 14)][- 2 * 0 + 14] + A[- 2 * 0 + 14 - 1][- 2 * 0 + 14]);
          A[- 2 * 0 + 2 + - 1][- 2 * 0 + 12 + - 1] = B[- 2 * 0 + 2 + - 1][- 2 * 0 + 12 + - 1];
          for (c5 = 15; c5 <= 16; c5++) {
            A[- 2 * 0 + 2 + - 1][- 2 * 0 + (c5 + -2) + - 1] = B[- 2 * 0 + 2 + - 1][- 2 * 0 + (c5 + -2) + - 1];
          }
        }
        for (c4 = 2 * c3 + 16; c4 <= 4 * c3 + 38; c4 = c4 + 2) {
          for (c5 = 2 * c3 + 4; c5 <= (((c4 + -7) * 2 < 0?((2 < 0?-((-(c4 + -7) + 2 + 1) / 2) : -((-(c4 + -7) + 2 - 1) / 2))) : (c4 + -7) / 2)); c5++) {
            A[- 2 * c3 + (c4 + -10) / 2 + - 1][- 2 * c3 + (c5 + -2) + - 1] = B[- 2 * c3 + (c4 + -10) / 2 + - 1][- 2 * c3 + (c5 + -2) + - 1];
          }
          A[14][- 2 * c3 + (c4 + -10) / 2 + - 1] = B[14][- 2 * c3 + (c4 + -10) / 2 + - 1];
          A[- 2 * c3 + (c4 + -10) / 2 + - 1][- 2 * c3 + (c4 + -10) / 2 + - 1] = B[- 2 * c3 + (c4 + -10) / 2 + - 1][- 2 * c3 + (c4 + -10) / 2 + - 1];
          for (c5 = ((c4 + -5) * 2 < 0?-(-(c4 + -5) / 2) : ((2 < 0?(-(c4 + -5) + - 2 - 1) / - 2 : (c4 + -5 + 2 - 1) / 2))); c5 <= ((2 * c3 + 16 < c4 + -1?2 * c3 + 16 : c4 + -1)); c5++) {
            A[- 2 * c3 + (c4 + -10) / 2 + - 1][- 2 * c3 + (c5 + -2) + - 1] = B[- 2 * c3 + (c4 + -10) / 2 + - 1][- 2 * c3 + (c5 + -2) + - 1];
          }
          if (c3 <= (((c4 + -17) * 2 < 0?((2 < 0?-((-(c4 + -17) + 2 + 1) / 2) : -((-(c4 + -17) + 2 - 1) / 2))) : (c4 + -17) / 2))) {
            A[- 2 * c3 + (c4 + -10) / 2 + - 1][14] = B[- 2 * c3 + (c4 + -10) / 2 + - 1][14];
          }
          if (2 * c3 == c4 + -16) {
            A[- 2 * c3 + (c3 + 3) + - 1][14] = B[- 2 * c3 + (c3 + 3) + - 1][14];
            A[- 2 * c3 + (c3 + 3) + - 1][- 2 * c3 + (2 * c3 + 14) + - 1] = B[- 2 * c3 + (c3 + 3) + - 1][- 2 * c3 + (2 * c3 + 14) + - 1];
          }
        }
        A[14][- 2 * c3 + (2 * c3 + 15) + - 1] = B[14][- 2 * c3 + (2 * c3 + 15) + - 1];
      }
    }
  }
  
#pragma endscop
  return 0;
}
