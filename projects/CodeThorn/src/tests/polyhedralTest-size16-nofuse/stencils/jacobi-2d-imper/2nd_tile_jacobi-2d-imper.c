#   define TSTEPS STEPSIZE
#   define N ARRAYSIZE
# define _PB_TSTEPS STEPSIZE 
# define _PB_N ARRAYSIZE 

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 16;
  int tsteps = 2;
/* Variable declaration/allocation. */
  double A[16][16];
  double B[16][16];
  int t;
  int i;
  int j;
  
#pragma scop
{
    int c2;
    int c0;
    int c3;
    for (c0 = 1; c0 <= 17; c0++) {
      for (c2 = (1 > c0 + - 13?1 : c0 + - 13); c2 <= ((17 < c0 + 13?17 : c0 + 13)); c2++) {
        if (c0 <= c2 + - 1 && c2 >= 15) {
          if ((c2 + 1) % 2 == 0) {
            A[c0 + - 1 * c2 + 14][14] = B[c0 + - 1 * c2 + 14][14];
          }
        }
        if (c0 >= ((15 > c2?15 : c2))) {
          if ((c0 + 1) % 2 == 0) {
            A[14][- 1 * c0 + c2 + 14] = B[14][- 1 * c0 + c2 + 14];
          }
        }
{
          int c5;
          if (c0 >= 2 && c0 <= 16 && c2 >= 2 && c2 <= 16 && c2 >= c0 + -12 && c2 <= c0 + 12) {
            for (c5 = (((0 > (((c0 + -14) * 2 < 0?-(-(c0 + -14) / 2) : ((2 < 0?(-(c0 + -14) + - 2 - 1) / - 2 : (c0 + -14 + 2 - 1) / 2))))?0 : (((c0 + -14) * 2 < 0?-(-(c0 + -14) / 2) : ((2 < 0?(-(c0 + -14) + - 2 - 1) / - 2 : (c0 + -14 + 2 - 1) / 2)))))) > (((c2 + -14) * 2 < 0?-(-(c2 + -14) / 2) : ((2 < 0?(-(c2 + -14) + - 2 - 1) / - 2 : (c2 + -14 + 2 - 1) / 2))))?((0 > (((c0 + -14) * 2 < 0?-(-(c0 + -14) / 2) : ((2 < 0?(-(c0 + -14) + - 2 - 1) / - 2 : (c0 + -14 + 2 - 1) / 2))))?0 : (((c0 + -14) * 2 < 0?-(-(c0 + -14) / 2) : ((2 < 0?(-(c0 + -14) + - 2 - 1) / - 2 : (c0 + -14 + 2 - 1) / 2)))))) : (((c2 + -14) * 2 < 0?-(-(c2 + -14) / 2) : ((2 < 0?(-(c2 + -14) + - 2 - 1) / - 2 : (c2 + -14 + 2 - 1) / 2))))); c5 <= ((((1 < (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2))?1 : (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2)))) < (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2))?((1 < (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2))?1 : (((c0 + -2) * 2 < 0?((2 < 0?-((-(c0 + -2) + 2 + 1) / 2) : -((-(c0 + -2) + 2 - 1) / 2))) : (c0 + -2) / 2)))) : (((c2 + -2) * 2 < 0?((2 < 0?-((-(c2 + -2) + 2 + 1) / 2) : -((-(c2 + -2) + 2 - 1) / 2))) : (c2 + -2) / 2)))); c5++) {
              A[c0 + - 2 * c5 + - 1][c2 + - 2 * c5 + - 1] = B[c0 + - 2 * c5 + - 1][c2 + - 2 * c5 + - 1];
              B[c0 + - 2 * c5][c2 + - 2 * c5] = 0.2 * (A[c0 + - 2 * c5][c2 + - 2 * c5] + A[c0 + - 2 * c5][c2 + - 2 * c5 - 1] + A[c0 + - 2 * c5][1 + (c2 + - 2 * c5)] + A[1 + (c0 + - 2 * c5)][c2 + - 2 * c5] + A[c0 + - 2 * c5 - 1][c2 + - 2 * c5]);
            }
          }
        }
        if (c0 >= c2 + 1 && c2 <= 3) {
          if ((c2 + 1) % 2 == 0) {
            B[c0 + - 1 * c2 + 1][1] = 0.2 * (A[c0 + - 1 * c2 + 1][1] + A[c0 + - 1 * c2 + 1][1 - 1] + A[c0 + - 1 * c2 + 1][1 + 1] + A[1 + (c0 + - 1 * c2 + 1)][1] + A[c0 + - 1 * c2 + 1 - 1][1]);
          }
        }
        if (c0 <= ((3 < c2?3 : c2))) {
          if ((c0 + 1) % 2 == 0) {
            B[1][- 1 * c0 + c2 + 1] = 0.2 * (A[1][- 1 * c0 + c2 + 1] + A[1][- 1 * c0 + c2 + 1 - 1] + A[1][1 + (- 1 * c0 + c2 + 1)] + A[1 + 1][- 1 * c0 + c2 + 1] + A[1 - 1][- 1 * c0 + c2 + 1]);
          }
        }
      }
    }
  }
  
#pragma endscop
  return 0;
}
