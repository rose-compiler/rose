/* Default data type is double, default size is 20x1000. */
#include "jacobi-2d-imper.h"

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 16;
  int tsteps = 2;
/* Variable declaration/allocation. */
  double A[16][16];
  double B[16][16];
  int t;
  int i;
  int j;
  
#pragma scop
{
    int c0;
    int c1;
    int c2;
{
      int c6;
      int c5;
      int c4;
      int c3;
      for (c3 = 0; c3 <= 1; c3++) {
        for (c4 = ((c3 + -1) * 2 < 0?-(-(c3 + -1) / 2) : ((2 < 0?(-(c3 + -1) + - 2 - 1) / - 2 : (c3 + -1 + 2 - 1) / 2))); c4 <= 5 * c3 + 47; c4++) {
          if (c3 >= 2 * c4 + -7) {
            if (c4 == 0) {
              B[1][- 2 * c3 + (2 * c3 + 1)] = 0.2 * (A[1][- 2 * c3 + (2 * c3 + 1)] + A[1][- 2 * c3 + (2 * c3 + 1) - 1] + A[1][1 + (- 2 * c3 + (2 * c3 + 1))] + A[1 + 1][- 2 * c3 + (2 * c3 + 1)] + A[1 - 1][- 2 * c3 + (2 * c3 + 1)]);
            }
            for (c6 = (4 * c4 > 2 * c3 + 2?4 * c4 : 2 * c3 + 2); c6 <= ((2 * c3 + 14 < 4 * c4 + 3?2 * c3 + 14 : 4 * c4 + 3)); c6++) {
              B[1][- 2 * c3 + c6] = 0.2 * (A[1][- 2 * c3 + c6] + A[1][- 2 * c3 + c6 - 1] + A[1][1 + (- 2 * c3 + c6)] + A[1 + 1][- 2 * c3 + c6] + A[1 - 1][- 2 * c3 + c6]);
              B[- 2 * c3 + c6][1] = 0.2 * (A[- 2 * c3 + c6][1] + A[- 2 * c3 + c6][1 - 1] + A[- 2 * c3 + c6][1 + 1] + A[1 + (- 2 * c3 + c6)][1] + A[- 2 * c3 + c6 - 1][1]);
            }
          }
          if (3 * c3 == c4 + -7) {
            for (c6 = 4 * c3 + 12; c6 <= 2 * c3 + 14; c6++) {
              B[- 2 * c3 + c6][- 2 * c3 + 4] = 0.2 * (A[- 2 * c3 + c6][- 2 * c3 + 4] + A[- 2 * c3 + c6][- 2 * c3 + 4 - 1] + A[- 2 * c3 + c6][1 + (- 2 * c3 + 4)] + A[1 + (- 2 * c3 + c6)][- 2 * c3 + 4] + A[- 2 * c3 + c6 - 1][- 2 * c3 + 4]);
            }
            A[14][- 2 * c3 + (2 * c3 + 2) + - 1] = B[14][- 2 * c3 + (2 * c3 + 2) + - 1];
            A[- 2 * c3 + (2 * c3 + 2) + - 1][- 2 * c3 + (2 * c3 + 2) + - 1] = B[- 2 * c3 + (2 * c3 + 2) + - 1][- 2 * c3 + (2 * c3 + 2) + - 1];
          }
          for (c5 = (2 * c3 + 4 > -1 * c3 + c4 + -9?2 * c3 + 4 : -1 * c3 + c4 + -9); c5 <= (((2 * c4 + -4) * 3 < 0?((3 < 0?-((-(2 * c4 + -4) + 3 + 1) / 3) : -((-(2 * c4 + -4) + 3 - 1) / 3))) : (2 * c4 + -4) / 3)); c5++) {
            for (c6 = 4 * c4 + -4 * c5; c6 <= 4 * c4 + -4 * c5 + 2; c6 = c6 + 2) {
              A[- 2 * c3 + (c6 + -10) / 2 + - 1][- 2 * c3 + (c5 + -2) + - 1] = B[- 2 * c3 + (c6 + -10) / 2 + - 1][- 2 * c3 + (c5 + -2) + - 1];
            }
          }
          if (c3 == 0 && c4 >= 24 && c4 <= 25) {
            if (c4 == 25) {
              A[- 2 * 0 + 13 + - 1][- 2 * 0 + 14 + - 1] = B[- 2 * 0 + 13 + - 1][- 2 * 0 + 14 + - 1];
            }
            A[14][- 2 * 0 + (c4 + -11) + - 1] = B[14][- 2 * 0 + (c4 + -11) + - 1];
            A[- 2 * 0 + (c4 + -11) + - 1][- 2 * 0 + (c4 + -11) + - 1] = B[- 2 * 0 + (c4 + -11) + - 1][- 2 * 0 + (c4 + -11) + - 1];
            if (c4 == 24) {
              A[- 2 * 0 + 14 + - 1][- 2 * 0 + 13 + - 1] = B[- 2 * 0 + 14 + - 1][- 2 * 0 + 13 + - 1];
            }
          }
          if (c3 == 0) {
            for (c5 = (2 > c4 + -3?2 : c4 + -3); c5 <= ((3 < c4?3 : c4)); c5++) {
              for (c6 = (2 > 4 * c4 + -4 * c5?2 : 4 * c4 + -4 * c5); c6 <= ((14 < 4 * c4 + -4 * c5 + 3?14 : 4 * c4 + -4 * c5 + 3)); c6++) {
                B[- 2 * 0 + c6][- 2 * 0 + c5] = 0.2 * (A[- 2 * 0 + c6][- 2 * 0 + c5] + A[- 2 * 0 + c6][- 2 * 0 + c5 - 1] + A[- 2 * 0 + c6][1 + (- 2 * 0 + c5)] + A[1 + (- 2 * 0 + c6)][- 2 * 0 + c5] + A[- 2 * 0 + c6 - 1][- 2 * 0 + c5]);
              }
            }
          }
          if (3 * c3 == c4 + -27) {
            A[14][- 2 * c3 + (2 * c3 + 15) + - 1] = B[14][- 2 * c3 + (2 * c3 + 15) + - 1];
          }
          c5 = ((2 * c4 + -3) * 3 < 0?-(-(2 * c4 + -3) / 3) : ((3 < 0?(-(2 * c4 + -3) + - 3 - 1) / - 3 : (2 * c4 + -3 + 3 - 1) / 3)));
          if (c5 <= (((((((-1 * c3 + 2 * c4 + -8) * 2 < 0?((2 < 0?-((-(-1 * c3 + 2 * c4 + -8) + 2 + 1) / 2) : -((-(-1 * c3 + 2 * c4 + -8) + 2 - 1) / 2))) : (-1 * c3 + 2 * c4 + -8) / 2)) < (((2 * c4 + -2) * 3 < 0?((3 < 0?-((-(2 * c4 + -2) + 3 + 1) / 3) : -((-(2 * c4 + -2) + 3 - 1) / 3))) : (2 * c4 + -2) / 3))?(((-1 * c3 + 2 * c4 + -8) * 2 < 0?((2 < 0?-((-(-1 * c3 + 2 * c4 + -8) + 2 + 1) / 2) : -((-(-1 * c3 + 2 * c4 + -8) + 2 - 1) / 2))) : (-1 * c3 + 2 * c4 + -8) / 2)) : (((2 * c4 + -2) * 3 < 0?((3 < 0?-((-(2 * c4 + -2) + 3 + 1) / 3) : -((-(2 * c4 + -2) + 3 - 1) / 3))) : (2 * c4 + -2) / 3)))) < 4 * c3 + 14?(((((-1 * c3 + 2 * c4 + -8) * 2 < 0?((2 < 0?-((-(-1 * c3 + 2 * c4 + -8) + 2 + 1) / 2) : -((-(-1 * c3 + 2 * c4 + -8) + 2 - 1) / 2))) : (-1 * c3 + 2 * c4 + -8) / 2)) < (((2 * c4 + -2) * 3 < 0?((3 < 0?-((-(2 * c4 + -2) + 3 + 1) / 3) : -((-(2 * c4 + -2) + 3 - 1) / 3))) : (2 * c4 + -2) / 3))?(((-1 * c3 + 2 * c4 + -8) * 2 < 0?((2 < 0?-((-(-1 * c3 + 2 * c4 + -8) + 2 + 1) / 2) : -((-(-1 * c3 + 2 * c4 + -8) + 2 - 1) / 2))) : (-1 * c3 + 2 * c4 + -8) / 2)) : (((2 * c4 + -2) * 3 < 0?((3 < 0?-((-(2 * c4 + -2) + 3 + 1) / 3) : -((-(2 * c4 + -2) + 3 - 1) / 3))) : (2 * c4 + -2) / 3)))) : 4 * c3 + 14))) {
            if (2 * c4 == 3 * c5 + 2) {
              if ((c4 + 2) % 3 == 0) {
                A[- 2 * c3 + (2 * c4 + -11) / 3 + - 1][- 2 * c3 + (2 * c4 + -8) / 3 + - 1] = B[- 2 * c3 + (2 * c4 + -11) / 3 + - 1][- 2 * c3 + (2 * c4 + -8) / 3 + - 1];
              }
            }
            A[14][- 2 * c3 + (c5 + -2) + - 1] = B[14][- 2 * c3 + (c5 + -2) + - 1];
            A[- 2 * c3 + (c5 + -2) + - 1][- 2 * c3 + (c5 + -2) + - 1] = B[- 2 * c3 + (c5 + -2) + - 1][- 2 * c3 + (c5 + -2) + - 1];
            if (2 * c4 == 3 * c5 + 3) {
              if (c4 % 3 == 0) {
                A[- 2 * c3 + (2 * c4 + -6) / 3 + - 1][- 2 * c3 + (2 * c4 + -9) / 3 + - 1] = B[- 2 * c3 + (2 * c4 + -6) / 3 + - 1][- 2 * c3 + (2 * c4 + -9) / 3 + - 1];
              }
            }
          }
          for (c5 = ((2 * c4 + -1) * 3 < 0?-(-(2 * c4 + -1) / 3) : ((3 < 0?(-(2 * c4 + -1) + - 3 - 1) / - 3 : (2 * c4 + -1 + 3 - 1) / 3))); c5 <= (((((-1 * c3 + 2 * c4 + -8) * 2 < 0?((2 < 0?-((-(-1 * c3 + 2 * c4 + -8) + 2 + 1) / 2) : -((-(-1 * c3 + 2 * c4 + -8) + 2 - 1) / 2))) : (-1 * c3 + 2 * c4 + -8) / 2)) < 4 * c3 + 14?(((-1 * c3 + 2 * c4 + -8) * 2 < 0?((2 < 0?-((-(-1 * c3 + 2 * c4 + -8) + 2 + 1) / 2) : -((-(-1 * c3 + 2 * c4 + -8) + 2 - 1) / 2))) : (-1 * c3 + 2 * c4 + -8) / 2)) : 4 * c3 + 14)); c5++) {
            for (c6 = 4 * c4 + -4 * c5; c6 <= 4 * c4 + -4 * c5 + 2; c6 = c6 + 2) {
              A[- 2 * c3 + (c6 + -10) / 2 + - 1][- 2 * c3 + (c5 + -2) + - 1] = B[- 2 * c3 + (c6 + -10) / 2 + - 1][- 2 * c3 + (c5 + -2) + - 1];
            }
          }
          if (c3 == 0) {
            for (c5 = (15 > (((2 * c4 + -1) * 3 < 0?-(-(2 * c4 + -1) / 3) : ((3 < 0?(-(2 * c4 + -1) + - 3 - 1) / - 3 : (2 * c4 + -1 + 3 - 1) / 3))))?15 : (((2 * c4 + -1) * 3 < 0?-(-(2 * c4 + -1) / 3) : ((3 < 0?(-(2 * c4 + -1) + - 3 - 1) / - 3 : (2 * c4 + -1 + 3 - 1) / 3))))); c5 <= ((16 < (((4 * c4 + -1) * 5 < 0?((5 < 0?-((-(4 * c4 + -1) + 5 + 1) / 5) : -((-(4 * c4 + -1) + 5 - 1) / 5))) : (4 * c4 + -1) / 5))?16 : (((4 * c4 + -1) * 5 < 0?((5 < 0?-((-(4 * c4 + -1) + 5 + 1) / 5) : -((-(4 * c4 + -1) + 5 - 1) / 5))) : (4 * c4 + -1) / 5)))); c5++) {
              for (c6 = 4 * c4 + -4 * c5; c6 <= 4 * c4 + -4 * c5 + 2; c6 = c6 + 2) {
                A[- 2 * 0 + (c6 + -10) / 2 + - 1][- 2 * 0 + (c5 + -2) + - 1] = B[- 2 * 0 + (c6 + -10) / 2 + - 1][- 2 * 0 + (c5 + -2) + - 1];
              }
            }
          }
          c5 = (-2 * ((-2 * c4 * 5 < 0?((5 < 0?-((-(-2 * c4) + 5 + 1) / 5) : -((-(-2 * c4) + 5 - 1) / 5))) : -2 * c4 / 5)) > 2 * c3 + 18?-2 * ((-2 * c4 * 5 < 0?((5 < 0?-((-(-2 * c4) + 5 + 1) / 5) : -((-(-2 * c4) + 5 - 1) / 5))) : -2 * c4 / 5)) : 2 * c3 + 18);
          if (c5 <= (((4 * c4 + 2) * 5 < 0?((5 < 0?-((-(4 * c4 + 2) + 5 + 1) / 5) : -((-(4 * c4 + 2) + 5 - 1) / 5))) : (4 * c4 + 2) / 5))) {
            A[- 2 * c3 + (c5 + -10) / 2 + - 1][14] = B[- 2 * c3 + (c5 + -10) / 2 + - 1][14];
          }
          if (5 * c3 == c4 + -17) {
            for (c6 = 4 * c3 + 12; c6 <= ((2 * c3 + 14 < 4 * c3 + 13?2 * c3 + 14 : 4 * c3 + 13)); c6++) {
              B[- 2 * c3 + c6][- 2 * c3 + (2 * c3 + 14)] = 0.2 * (A[- 2 * c3 + c6][- 2 * c3 + (2 * c3 + 14)] + A[- 2 * c3 + c6][- 2 * c3 + (2 * c3 + 14) - 1] + A[- 2 * c3 + c6][1 + (- 2 * c3 + (2 * c3 + 14))] + A[1 + (- 2 * c3 + c6)][- 2 * c3 + (2 * c3 + 14)] + A[- 2 * c3 + c6 - 1][- 2 * c3 + (2 * c3 + 14)]);
            }
            if (c3 == 1) {
              A[- 2 * 1 + 4 + - 1][14] = B[- 2 * 1 + 4 + - 1][14];
            }
            if (c3 == 0) {
              A[- 2 * 0 + 2 + - 1][14] = B[- 2 * 0 + 2 + - 1][14];
              B[- 2 * 0 + 14][- 2 * 0 + 14] = 0.2 * (A[- 2 * 0 + 14][- 2 * 0 + 14] + A[- 2 * 0 + 14][- 2 * 0 + 14 - 1] + A[- 2 * 0 + 14][1 + (- 2 * 0 + 14)] + A[1 + (- 2 * 0 + 14)][- 2 * 0 + 14] + A[- 2 * 0 + 14 - 1][- 2 * 0 + 14]);
            }
            A[- 2 * c3 + (2 * c3 + 2) + - 1][- 2 * c3 + (4 * c3 + 12) + - 1] = B[- 2 * c3 + (2 * c3 + 2) + - 1][- 2 * c3 + (4 * c3 + 12) + - 1];
          }
          if (c3 <= (((c4 + -8) * 3 < 0?((3 < 0?-((-(c4 + -8) + 3 + 1) / 3) : -((-(c4 + -8) + 3 - 1) / 3))) : (c4 + -8) / 3)) && c3 >= (((c4 + -16) * 5 < 0?-(-(c4 + -16) / 5) : ((5 < 0?(-(c4 + -16) + - 5 - 1) / - 5 : (c4 + -16 + 5 - 1) / 5))))) {
            for (c6 = 4 * c3 + 12; c6 <= 2 * c3 + 14; c6++) {
              B[- 2 * c3 + c6][- 2 * c3 + (-3 * c3 + c4 + -3)] = 0.2 * (A[- 2 * c3 + c6][- 2 * c3 + (-3 * c3 + c4 + -3)] + A[- 2 * c3 + c6][- 2 * c3 + (-3 * c3 + c4 + -3) - 1] + A[- 2 * c3 + c6][1 + (- 2 * c3 + (-3 * c3 + c4 + -3))] + A[1 + (- 2 * c3 + c6)][- 2 * c3 + (-3 * c3 + c4 + -3)] + A[- 2 * c3 + c6 - 1][- 2 * c3 + (-3 * c3 + c4 + -3)]);
            }
            A[- 2 * c3 + (2 * c3 + 2) + - 1][- 2 * c3 + (-1 * c3 + c4 + -5) + - 1] = B[- 2 * c3 + (2 * c3 + 2) + - 1][- 2 * c3 + (-1 * c3 + c4 + -5) + - 1];
          }
          if (c3 == 0 && c4 == 20) {
            A[- 2 * 0 + 3 + - 1][14] = B[- 2 * 0 + 3 + - 1][14];
            for (c6 = 16; c6 <= 18; c6 = c6 + 2) {
              A[- 2 * 0 + (c6 + -10) / 2 + - 1][- 2 * 0 + 14 + - 1] = B[- 2 * 0 + (c6 + -10) / 2 + - 1][- 2 * 0 + 14 + - 1];
            }
          }
          if (c3 == 0 && c4 >= 18 && c4 <= 19) {
            A[- 2 * 0 + 2 + - 1][- 2 * 0 + (c4 + -5) + - 1] = B[- 2 * 0 + 2 + - 1][- 2 * 0 + (c4 + -5) + - 1];
          }
          for (c5 = (2 * c3 + 4 > -1 * c3 + c4 + -2?2 * c3 + 4 : -1 * c3 + c4 + -2); c5 <= (((((-1 * c3 + 2 * c4) * 2 < 0?((2 < 0?-((-(-1 * c3 + 2 * c4) + 2 + 1) / 2) : -((-(-1 * c3 + 2 * c4) + 2 - 1) / 2))) : (-1 * c3 + 2 * c4) / 2)) < 4 * c3 + 14?(((-1 * c3 + 2 * c4) * 2 < 0?((2 < 0?-((-(-1 * c3 + 2 * c4) + 2 + 1) / 2) : -((-(-1 * c3 + 2 * c4) + 2 - 1) / 2))) : (-1 * c3 + 2 * c4) / 2)) : 4 * c3 + 14)); c5++) {
            for (c6 = (2 * c3 + 2 > 4 * c4 + -4 * c5?2 * c3 + 2 : 4 * c4 + -4 * c5); c6 <= 4 * c4 + -4 * c5 + 3; c6++) {
              B[- 2 * c3 + c6][- 2 * c3 + (-2 * c3 + c5)] = 0.2 * (A[- 2 * c3 + c6][- 2 * c3 + (-2 * c3 + c5)] + A[- 2 * c3 + c6][- 2 * c3 + (-2 * c3 + c5) - 1] + A[- 2 * c3 + c6][1 + (- 2 * c3 + (-2 * c3 + c5))] + A[1 + (- 2 * c3 + c6)][- 2 * c3 + (-2 * c3 + c5)] + A[- 2 * c3 + c6 - 1][- 2 * c3 + (-2 * c3 + c5)]);
            }
          }
        }
      }
    }
  }
  
#pragma endscop
  return 0;
}
