#   define N ARRAYSIZE
# define _PB_N ARRAYSIZE
/**
 * trisolv.c: This file is part of the PolyBench/C 3.2 test suite.
 *
 *
 * Contact: Louis-Noel Pouchet <pouchet@cse.ohio-state.edu>
 * Web address: http://polybench.sourceforge.net
 */
#include <stdio.h>
#include <unistd.h>
#include <string.h>
#include <math.h>

int main(int argc,char **argv)
{
/* Retrieve problem size. */
  int n = 16;
/* Variable declaration/allocation. */
  double A[16][16];
  double x[16];
  double c[16];
  int i;
  int j;
  
#pragma scop
{
    int c1;
    int c2;
    int c3;
{
      int c2;
      int c4;
      for (c2 = 0; c2 <= 15; c2++) {
        c4 = (c2 * 13 < 0?((13 < 0?-((-c2 + 13 + 1) / 13) : -((-c2 + 13 - 1) / 13))) : c2 / 13);
        x[c2] = c[c2];
      }
    }
    for (c1 = 0; c1 <= 16; c1++) {
      if (c1 <= 12) {
        
#pragma omp parallel for private(c3)
{
          int c0;
          int c5;
          int c4;
          if (c1 >= 2 && c1 <= 16) {
            c0 = ((c1 + -11) * 11 < 0?-(-(c1 + -11) / 11) : ((11 < 0?(-(c1 + -11) + - 11 - 1) / - 11 : (c1 + -11 + 11 - 1) / 11)));
            if (c0 <= (((c1 + -2) * 10 < 0?((10 < 0?-((-(c1 + -2) + 10 + 1) / 10) : -((-(c1 + -2) + 10 - 1) / 10))) : (c1 + -2) / 10))) {
              for (c4 = ((((((-13 * c1 + 156) * 10 < 0?-(-(-13 * c1 + 156) / 10) : ((10 < 0?(-(-13 * c1 + 156) + - 10 - 1) / - 10 : (-13 * c1 + 156 + 10 - 1) / 10)))) > ((13 * c1 * 14 < 0?-(-(13 * c1) / 14) : ((14 < 0?(-(13 * c1) + - 14 - 1) / - 14 : (13 * c1 + 14 - 1) / 14))))?(((-13 * c1 + 156) * 10 < 0?-(-(-13 * c1 + 156) / 10) : ((10 < 0?(-(-13 * c1 + 156) + - 10 - 1) / - 10 : (-13 * c1 + 156 + 10 - 1) / 10)))) : ((13 * c1 * 14 < 0?-(-(13 * c1) / 14) : ((14 < 0?(-(13 * c1) + - 14 - 1) / - 14 : (13 * c1 + 14 - 1) / 14)))))) > -143 * c0 + 13 * c1 + -130?(((((-13 * c1 + 156) * 10 < 0?-(-(-13 * c1 + 156) / 10) : ((10 < 0?(-(-13 * c1 + 156) + - 10 - 1) / - 10 : (-13 * c1 + 156 + 10 - 1) / 10)))) > ((13 * c1 * 14 < 0?-(-(13 * c1) / 14) : ((14 < 0?(-(13 * c1) + - 14 - 1) / - 14 : (13 * c1 + 14 - 1) / 14))))?(((-13 * c1 + 156) * 10 < 0?-(-(-13 * c1 + 156) / 10) : ((10 < 0?(-(-13 * c1 + 156) + - 10 - 1) / - 10 : (-13 * c1 + 156 + 10 - 1) / 10)))) : ((13 * c1 * 14 < 0?-(-(13 * c1) / 14) : ((14 < 0?(-(13 * c1) + - 14 - 1) / - 14 : (13 * c1 + 14 - 1) / 14)))))) : -143 * c0 + 13 * c1 + -130); c4 <= 15; c4++) {
                c5 = ((-1 * c4 + 13 * c1) * 13 < 0?-(-(-1 * c4 + 13 * c1) / 13) : ((13 < 0?(-(-1 * c4 + 13 * c1) + - 13 - 1) / - 13 : (-1 * c4 + 13 * c1 + 13 - 1) / 13)));
                if (c5 <= (((((11 * c1 + -12) * 10 < 0?((10 < 0?-((-(11 * c1 + -12) + 10 + 1) / 10) : -((-(11 * c1 + -12) + 10 - 1) / 10))) : (11 * c1 + -12) / 10)) < (((-1 * c4 + 13 * c1 + 12) * 13 < 0?((13 < 0?-((-(-1 * c4 + 13 * c1 + 12) + 13 + 1) / 13) : -((-(-1 * c4 + 13 * c1 + 12) + 13 - 1) / 13))) : (-1 * c4 + 13 * c1 + 12) / 13))?(((11 * c1 + -12) * 10 < 0?((10 < 0?-((-(11 * c1 + -12) + 10 + 1) / 10) : -((-(11 * c1 + -12) + 10 - 1) / 10))) : (11 * c1 + -12) / 10)) : (((-1 * c4 + 13 * c1 + 12) * 13 < 0?((13 < 0?-((-(-1 * c4 + 13 * c1 + 12) + 13 + 1) / 13) : -((-(-1 * c4 + 13 * c1 + 12) + 13 - 1) / 13))) : (-1 * c4 + 13 * c1 + 12) / 13))))) {
                  x[c4] = x[c4] - A[c4][c5 + - 1] * x[c5 + - 1];
                }
              }
            }
          }
        }
      }
{
        if (c1 == 0) {
          x[0] = x[0] / A[0][0];
        }
        c2 = (1 > (((13 * c1 + - 1) * 14 < 0?-(-(13 * c1 + - 1) / 14) : ((14 < 0?(-(13 * c1 + - 1) + - 14 - 1) / - 14 : (13 * c1 + - 1 + 14 - 1) / 14))))?1 : (((13 * c1 + - 1) * 14 < 0?-(-(13 * c1 + - 1) / 14) : ((14 < 0?(-(13 * c1 + - 1) + - 14 - 1) / - 14 : (13 * c1 + - 1 + 14 - 1) / 14)))));
      }
{
        int c5;
        if (13 * c1 >= 14 * c2 + -11) {
          if (c1 <= ((14 * c2 * 13 < 0?((13 < 0?-((-(14 * c2) + 13 + 1) / 13) : -((-(14 * c2) + 13 - 1) / 13))) : 14 * c2 / 13)) && c2 >= 15) {
            x[c2] = x[c2] - A[c2][c2 + - 1] * x[c2 + - 1];
          }
          if (c1 >= (((14 * c2 + 1) * 13 < 0?-(-(14 * c2 + 1) / 13) : ((13 < 0?(-(14 * c2 + 1) + - 13 - 1) / - 13 : (14 * c2 + 1 + 13 - 1) / 13)))) && c2 >= -1 && c2 <= 14) {
            x[c2] = x[c2] / A[c2][c2];
            x[c2 + 1] = x[c2 + 1] - A[c2 + 1][c2 + - 1] * x[c2 + - 1];
          }
          for (c5 = c2 + 2; c5 <= ((-1 < 13 * c1 + -13 * c2 + 12?-1 : 13 * c1 + -13 * c2 + 12)); c5++) {
            x[c5] = x[c5] - A[c5][c2 + - 1] * x[c2 + - 1];
          }
          if (c1 <= ((14 * c2 * 13 < 0?((13 < 0?-((-(14 * c2) + 13 + 1) / 13) : -((-(14 * c2) + 13 - 1) / 13))) : 14 * c2 / 13)) && c2 <= 14) {
            x[c2] = x[c2] - A[c2][c2 + - 1] * x[c2 + - 1];
            x[c2] = x[c2] / A[c2][c2];
            x[c2 + 1] = x[c2 + 1] - A[c2 + 1][c2 + - 1] * x[c2 + - 1];
          }
          if (c1 >= c2 && c2 <= -2) {
            x[c2] = x[c2] / A[c2][c2];
            x[c2 + 1] = x[c2 + 1] - A[c2 + 1][c2 + - 1] * x[c2 + - 1];
            x[0] = x[0] - A[0][c2 + - 1] * x[c2 + - 1];
          }
          if (c1 >= (((14 * c2 + 1) * 13 < 0?-(-(14 * c2 + 1) / 13) : ((13 < 0?(-(14 * c2 + 1) + - 13 - 1) / - 13 : (14 * c2 + 1 + 13 - 1) / 13)))) && c1 <= c2 + -1) {
            x[c2] = x[c2] / A[c2][c2];
            x[c2 + 1] = x[c2 + 1] - A[c2 + 1][c2 + - 1] * x[c2 + - 1];
          }
          for (c5 = (1 > c2 + 2?1 : c2 + 2); c5 <= ((15 < 13 * c1 + -13 * c2 + 12?15 : 13 * c1 + -13 * c2 + 12)); c5++) {
            x[c5] = x[c5] - A[c5][c2 + - 1] * x[c2 + - 1];
          }
          if (c1 == 16 && c2 == 15) {
            x[15] = x[15] / A[15][15];
          }
        }
      }
    }
  }
  
#pragma endscop
  return 0;
}
