#if 0
int& foo(int& a)
{
    return a = 0;
}

void test0()
{
    int i = 0, j = 0, k = 0;

    /*****************************************/
    i = j = k;
    i = j++, i = j = k;
    (j += (k += 1));
    i += (j += (k += 1));
    i = (k *= 2, j += (k += 1));

    /*****************************************/
    (++i, j) = k;

    /*****************************************/
    (i += 1) + (j += 1);

    /*****************************************/
    i = ++j;
    i = j++;

    /*****************************************/
    ++++i;
    ++++++++i;

    /*****************************************/
    i = (j++) * 2;
    j = i + ++i;
    j = i++ + i;
    (j = i, j = ++i);

    /*****************************************/
    i = (j++, (k++, k = 4));

    /*****************************************/
    if (i = j);
    if (i == (j = k));
    if (i = j++);

    /*****************************************/
    i = (i ? ++j : k++);

    /*****************************************/
    ((i += 1, i += 2), (i += 3, i += 4));

    /*****************************************/
    (i = j) || (j = k = i);
    (i = j) + (j = k = i);
    k = (i++ || j++);

    // Unary test.
    ++(i = j);
    !(i = j);

    // Logical or and and
    (i += j) || (j += k);

    // Function calls.
    //i = foo(j);
    //++foo(j);
}

#endif

void foo() { int i; i = 2;}
